# Repository liqunmaster/Dust_HeavyRobot

File README:

# Dust_HeavyRobot

同一仓库中的两个独立 Zephyr 固件工程：

- `firmware/Dust_HeavyRobot_H`：yaw、pitch、shoot 与 H 板间桥接。
- `firmware/Dust_HeavyRobot_L`：chassis、liftup、booster 与 L 板间桥接。

两端板间通信实现各自命名为 `App/mcu_common.cpp/.hpp`；公共输入映射位于 `firmware/common/input_manager.*`，仿真子模块位于 `firmware/test`。公共构建装配为 `cmake/mcu_common.cmake`。

共享 `math/`、`Topic/msg/`、协议、驱动和公共模块。两个工程各自持有入口、配置、应用清单与编译数据库。

在 PowerShell 中通过唯一构建烧录入口操作：

```powershell
& '.\Script\build&flash.cmd' H Build
& '.\Script\build&flash.cmd' L Build
& '.\Script\build&flash.cmd' H Flash
& '.\Script\build&flash.cmd' L Flash Vllink
```

完整参数为 `[H|L] [Build|Flash|Server] [Auto|Vllink|DAP] [10..4000 kHz]`，缺省为 `H Flash Auto 10`。`Auto` 默认 H、L 均使用 Vllink，速度均为 10 kHz；VS Code 的 `Debug H`、`Debug L` 也均使用 Vllink。当前工具链配置为本机 `D:/MCU/` 安装位置。

产物位于 `build/build_h/zephyr/`、`build/build_l/zephyr/`，名称仍为 `Dust_HeavyRobot.elf`、`Dust_HeavyRobot.bin`。VS Code 构建烧录任务也调用同一 cmd。

架构、消息使用和迁移验证详见 [第一阶段实施记录](Doc/双板架构第一阶段实施记录.md)。线程调度与离线策略的后续方案见 [实施方案](Doc/架构改造实施方案_待审核.md)。

## KiCad design Board/hpm5361/doc/HPM5361/HPM5361主控板.kicad_pcb

Parts:
C33, C35, C36, C37, C38, C39, C40, C42, C43, C44: 100nF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C34, C41: 10uF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C45, C46: 4.7uF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
U3: HPM5361ICB1; LQFP-100_14x14mm_P0.5mm

Connections:
+3.3V: C33.1, C34.1, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.1, C42.1, U3.9 (VIO_B00), U3.15 (VIO_B00), U3.31 (VPMC), U3.42 (VIO_B01), U3.55 (VIO_B01), U3.71 (VPLL), U3.85 (VIO_B00), U3.96 (VIO_B00); also elsewhere on the board
BOOT0: U3.19 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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); also elsewhere on the board
BOOT1: U3.18 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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); also elsewhere on the board
CAN0_RXD: U3.62 (PB01/TMR1.CAPT0/URT0.RXD/CAN0.RXD/PWM0.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); also elsewhere on the board
CAN0_TXD: U3.63 (PB00/TMR1.COMP0/URT0.TXD/CAN0.TXD/PWM0.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); also elsewhere on the board
CAN1_RXD: U3.59 (PB04/URT1.CTS/SPI3.CS0/CAN1.RXD/PWM0.P4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); also elsewhere on the board
CAN1_TXD: U3.58 (PB05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI3.S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); also elsewhere on the board
CAN2_RXD: U3.40 (PY01/TMR3.CAPT0/URT0.RXD/CAN2.RXD/PWM0.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); also elsewhere on the board
CAN2_TXD: U3.41 (PY00/TMR3.COMP0/URT0.TXD/CAN2.TXD/PWM0.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); also elsewhere on the board
CAN3_RXD: U3.37 (PY04/URT1.CTS/SPI2.CS0/CAN3.RXD/PWM0.P4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); also elsewhere on the board
CAN3_TXD: U3.36 (PY05/TMR3.COMP2/URT1.DE/URT1.RTS/SPI2.S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); also elsewhere on the board
GND: C33.2, C34.2, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.2, C42.2, C43.1, C44.1, C45.1, C46.1; also elsewhere on the board
INT1: U3.45 (PB15/TMR0.COMP3/URT3.TXD/SPI2.DAT3/CAN3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); also elsewhere on the board
INT2: U3.46 (PB14/URT3.RXD/SPI2.DAT2/CAN3.RXD/PWM0.F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); also elsewhere on the board
JTAG_TCK: U3.100 (PA06/TMR0.CAPT0/URT1.RXD/I2C1.SDA/SPI0.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); also elsewhere on the board
JTAG_TDI: U3.1 (PA05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI0.S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); also elsewhere on the board
JTAG_TDO: U3.2 (PA04/URT1.CTS/SPI0.CS0/CAN1.RXD/PWM0.P0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); also elsewhere on the board
JTAG_TMS: U3.99 (PA07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI0.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); also elsewhere on the board
JTAG_TRST: U3.3 (PA08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI3.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); also elsewhere on the board
unnamed: C44.2, C46.2, U3.23 (VDD_OTPCAP)
unnamed: C43.2, C45.2, U3.33 (VDD_PMCCAP)
PWM0_P5: U3.4 (PA09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI3.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); also elsewhere on the board
PWM0_P6: U3.5 (PA10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI3.C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); also elsewhere on the board
PWM0_P7: U3.53 (PB07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI3.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); also elsewhere on the board
PWM1_P2: U3.93 (PA18/TMR3.COMP1/URT4.DE/URT4.RTS/I2C0.S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); also elsewhere on the board
PWM1_P3: U3.92 (PA19/TMR3.CAPT1/URT4.CTS/I2C0.SDA/SPI1.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); also elsewhere on the board
PWM1_P4: U3.91 (PA20/URT5.CTS/SPI2.CS0/CAN1.RXD/PWM0.FA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)
SPI1_CS: U3.82 (PA26/TMR2.COMP2/URT6.DE/URT6.RTS/SPI1.C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); also elsewhere on the board
SPI1_D2: U3.78 (PA30/URT7.RXD/SPI1.DAT2/CAN3.RXD/XPI0.C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); also elsewhere on the board
SPI1_D3: U3.77 (PA31/TMR2.COMP3/URT7.TXD/SPI1.DAT3/CAN3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); also elsewhere on the board
SPI1_MISO: U3.80 (PA28/URT7.CTS/I2C3.SDA/SPI1.MISO/XPI0.C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); also elsewhere on the board
SPI1_MOSI: U3.79 (PA29/TMR3.COMP3/URT7.DE/URT7.RTS/I2C3.S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); also elsewhere on the board
SPI1_SCLK: U3.81 (PA27/URT6.CTS/SPI1.SCLK/XPI0.CA_SCLK/PW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); also elsewhere on the board
SPI2_CS: U3.50 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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); also elsewhere on the board
SPI2_MISO: U3.48 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/PWM1.F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); also elsewhere on the board
SPI2_MOSI: U3.47 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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); also elsewhere on the board
SPI2_SCLK: U3.49 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/PWM1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); also elsewhere on the board
UART0_RXD: U3.24 (PA01/TMR1.CAPT0/URT0.RXD/CAN0.RXD/PWM0.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); also elsewhere on the board
UART0_TXD: U3.25 (PA00/TMR1.COMP0/URT0.TXD/CAN0.TXD/PWM0.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); also elsewhere on the board
UART1_RXD: U3.35 (PY06/TMR2.CAPT0/URT1.RXD/I2C3.SDA/SPI2.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); also elsewhere on the board
UART1_TXD: U3.34 (PY07/TMR2.COMP0/URT1.TXD/I2C3.SCL/SPI2.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); also elsewhere on the board
UART2_RXD: U3.51 (PB09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI2.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); also elsewhere on the board
UART2_TXD: U3.52 (PB08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI2.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); also elsewhere on the board
UART3_RXD: U3.13 (PA14/URT3.RXD/SPI3.DAT2/CAN3.RXD/PWM0.P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); also elsewhere on the board
UART3_TXD: U3.14 (PA15/TMR0.COMP3/URT3.TXD/SPI3.DAT3/CAN3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); also elsewhere on the board
UART4_RXD: U3.97 (PA17/TMR3.CAPT0/URT4.RXD/CAN0.RXD/PWM0.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); also elsewhere on the board
UART4_TXD: U3.98 (PA16/TMR3.COMP0/URT4.TXD/CAN0.TXD/PWM0.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)
UART5_DE: U3.90 (PA21/TMR3.COMP2/URT5.DE/URT5.RTS/SPI2.S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); also elsewhere on the board
UART5_RXD: U3.89 (PA22/TMR2.CAPT0/URT5.RXD/I2C1.SDA/SPI2.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); also elsewhere on the board
UART5_TXD: U3.88 (PA23/TMR2.COMP0/URT5.TXD/I2C1.SCL/SPI2.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); also elsewhere on the board
UART6_RXD: U3.86 (PA25/TMR2.CAPT1/URT6.RXD/I2C2.SDA/SPI1.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); also elsewhere on the board
UART6_TXD: U3.87 (PA24/TMR2.COMP1/URT6.TXD/I2C2.SCL/SPI1.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); also elsewhere on the board
User_Key: U3.38 (PY03/TMR3.CAPT1/URT0.CTS/I2C2.SDA/CAN3.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); also elsewhere on the board

Parts:
C47, C48, C49, C50, C51, C52, C53, C54, C56, C57, C58, C59, C60, C61, C62, C63: 100nF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
D10: SD103AWS S4; D_SOD-323
D11, D12, D14, D16, D18, D19, D20, D21, D26, D27, D29, D30: ESD9B5.0ST5G; D_SOD-923
D13: WS2812B; LED_WS2812B-Mini_PLCC4_3.5x3.5mm
D15: PSM712; SOT-23-3
D22, D23, D24, D25: PESD1CAN; SOT-23-3
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10: BSMD0603-005-15V; Fuse_0603_1608Metric
F11, F12, F13, F14, F15, F16, F18, F19, F20, F21, F22, F23: SMD0402; Fuse_0402_1005Metric
H1, H2: JST_GH_BM03B-GHS-TBT_1x03-1MP_P1.25mm_Vertical
H3, H4, H5: JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
H6, H7, H8, H9: JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J2: Conn_02x05_Counter_Clockwise_MountingPin; CONN-TH_10P-P1.27_HX-JN1.27-2X5P-ZZ-H4.9
J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J4, J5, J7: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
KEY1, KEY2: 笑脸开关3*5; SW_Push_1P1T-MP_NO_Horizontal_Alps_SKRTLAE010
L4, L5, L6, L7: ACM2012(90欧); L_CommonModeChoke_Coilank_ACM3225
MLT-1: BUZ-SMD_L5.0-W5.5-P4.60
Q2, Q3: PMBT3904; SOT-23
Q4: AO3404A; SOT-23
R21, R27, R33: 10k; R_0402_1005Metric
R22, R26, R28, R30, R31, R32, R34, R35, R36, R39: 10K; R_0402_1005Metric
R23, R25: 0; R_0402_1005Metric
R24: 4.7K; R_0402_1005Metric
R29: 1K; R_0402_1005Metric
R37, R48, R49, R50, R51: 120; R_0402_1005Metric
R38: 33R; R_0402_1005Metric
R40: 36R; R_1206_3216Metric
U6: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U7: SN65HVD75DRBR; VSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
U8: ICM-42688P-HXY; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U9, U10, U11, U12: TJA1042TK-3; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm

Connections:
+3.3V: C48.1, C49.1, C52.1, C53.1, C54.1, C56.2, C57.2, C58.2, C59.2, D10.1 (K), J2.8, MLT-1.1 (+), R22.2, R23.2, R24.2, R25.2, R28.2, R31.2, R32.2, R34.2, R35.2, U6.8 (VCC), U7.8 (VCC), U8.5 (VDDIO), U8.8 (VDD), U9.5 (VIO), U10.5 (VIO), U11.5 (VIO), U12.5 (VIO); also elsewhere on the board
+5V: C60.1, C61.1, C62.1, C63.1, D13.1 (VDD), H3.3, H4.1, H5.1, J2.10, J3.2, J4.1, J4.2, R40.1, U9.3 (VCC), U10.3 (VCC), U11.3 (VCC), U12.3 (VCC); also elsewhere on the board
A: F2.2, H3.2
B: F1.2, H3.1
BOOT0: R21.1, R23.1; also elsewhere on the board
BOOT1: R25.1, R27.2; also elsewhere on the board
CAN0_H: F3.2, H9.2
CAN0_L: F4.2, H9.1
CAN0_RXD: U12.4 (RXD); also elsewhere on the board
CAN0_TXD: U12.1 (TXD); also elsewhere on the board
CAN1_H: F5.2, H6.2
CAN1_L: F6.2, H6.1
CAN1_RXD: U9.4 (RXD); also elsewhere on the board
CAN1_TXD: U9.1 (TXD); also elsewhere on the board
CAN2_H: F7.2, H7.2
CAN2_L: F8.2, H7.1
CAN2_RXD: U10.4 (RXD); also elsewhere on the board
CAN2_TXD: U10.1 (TXD); also elsewhere on the board
CAN3_H: F9.2, H8.2
CAN3_L: F10.2, H8.1
CAN3_RXD: U11.4 (RXD); also elsewhere on the board
CAN3_TXD: U11.1 (TXD); also elsewhere on the board
DBUS: J3.1, Q2.1 (B)
GND: C47.2, C49.2, C50.1, C51.2, C52.2, C53.2, C54.2, C56.1, C57.1, C58.1, C59.1, C60.2, C61.2, C62.2, C63.2, D11.1 (A1), D12.1 (A1), D13.3 (VSS), D14.1 (A1), D15.3 (A), D16.1 (A1), D18.1 (A1), D19.1 (A1), D20.1 (A1), D21.1 (A1), D22.3 (A), D23.3 (A), D24.3 (A), D25.3 (A), D26.1 (A1), D27.1 (A1), D29.1 (A1), D30.1 (A1), H1.1, H1.MP, H2.1, H2.MP, H3.4, H3.MP, H4.2, H4.MP, H5.2, H5.MP, H6.MP, H7.MP, H8.MP, H9.MP, J2.9, J3.3, J5.1, J5.2, KEY1.1, KEY1.MP, KEY2.1, KEY2.MP, MLT-1.3 (NC), Q2.2 (E), Q3.2 (E), Q4.2 (S), R21.2, R26.2, R27.1, R30.2, R33.1, R36.1, R39.1, U6.4 (GND), U7.5 (GND), U7.9 (PAD), U8.6 (GNDIO), U8.7 (GND), U9.2 (GND), U9.8 (STB), U9.9 (GND), U10.2 (GND), U10.8 (STB), U10.9 (GND), U11.2 (GND), U11.8 (STB), U11.9 (GND), U12.2 (GND), U12.8 (STB), U12.9 (GND); also elsewhere on the board
INT1: U8.4 (INT1); also elsewhere on the board
INT2: U8.9 (INT2); also elsewhere on the board
JTAG_TCK: J2.3, R26.1; also elsewhere on the board
JTAG_TDI: J2.1, R32.1; also elsewhere on the board
JTAG_TDO: J2.5; also elsewhere on the board
JTAG_TMS: J2.2, R31.1; also elsewhere on the board
JTAG_TRST: J2.4; also elsewhere on the board
unnamed: C48.2, D10.2 (A), MLT-1.2 (-), Q3.3 (C)
unnamed: D22.1 (K), F5.1, L4.4
unnamed: D22.2 (K), F6.1, L4.3
unnamed: D23.1 (K), F7.1, L5.4
unnamed: D23.2 (K), F8.1, L5.3
unnamed: D24.1 (K), F9.1, L6.4
unnamed: D24.2 (K), F10.1, L6.3
unnamed: D25.1 (K), F4.1, L7.3
unnamed: D25.2 (K), F3.1, L7.4
unnamed: F11.2, H4.3
unnamed: F12.2, H4.4
unnamed: F13.2, H2.2
unnamed: F14.2, H2.3
unnamed: F15.2, H1.2
unnamed: F16.2, H1.3
unnamed: F22.2, H5.3
unnamed: F23.2, H5.4
unnamed: F21.1, J2.6
unnamed: F20.1, J2.7
unnamed: F19.2, J7.1
unnamed: F18.2, J7.2
unnamed: Q3.1 (B), R29.1, R30.1
unnamed: Q4.3 (D), R40.2
unnamed: Q4.1 (G), R38.1
unnamed: D15.2 (K), F2.1, R37.1, U7.6 (A)
unnamed: D15.1 (K), F1.1, R37.2, U7.7 (B)
unnamed: L4.1, R48.2, U9.7 (CANH)
unnamed: L4.2, R48.1, U9.6 (CANL)
unnamed: L5.1, R49.2, U10.7 (CANH)
unnamed: L5.2, R49.1, U10.6 (CANL)
unnamed: L6.1, R50.2, U11.7 (CANH)
unnamed: L6.2, R50.1, U11.6 (CANL)
unnamed: L7.1, R51.2, U12.7 (CANH)
unnamed: L7.2, R51.1, U12.6 (CANL)
PWM0_P5: R29.2; also elsewhere on the board
PWM0_P6: D13.4 (DIN); also elsewhere on the board
PWM0_P7: R38.2, R39.2; also elsewhere on the board
PWM1_P2: D27.2 (A2), F18.1; also elsewhere on the board
PWM1_P3: D26.2 (A2), F19.1; also elsewhere on the board
RESET: C47.1, KEY1.2, R22.1; also elsewhere on the board
SPI1_CS: R28.1, U6.1 (~CS); also elsewhere on the board
SPI1_D2: U6.3 (~WP/IO_{2}); also elsewhere on the board
SPI1_D3: U6.7 (~HOLD/~RESET/IO_{3}); also elsewhere on the board
SPI1_MISO: U6.2 (DO/IO_{1}); also elsewhere on the board
SPI1_MOSI: U6.5 (DI/IO_{0}); also elsewhere on the board
SPI1_SCLK: U6.6 (CLK); also elsewhere on the board
SPI2_CS: U8.12 (CSB); also elsewhere on the board
SPI2_MISO: U8.1 (SDO/SA0); also elsewhere on the board
SPI2_MOSI: U8.14 (SDX); also elsewhere on the board
SPI2_SCLK: U8.13 (SCX); also elsewhere on the board
UART0_RXD: D18.2 (A2), F11.1; also elsewhere on the board
UART0_TXD: D20.2 (A2), F12.1; also elsewhere on the board
UART1_RXD: D16.2 (A2), F13.1; also elsewhere on the board
UART1_TXD: D14.2 (A2), F14.1; also elsewhere on the board
UART2_RXD: D11.2 (A2), F15.1; also elsewhere on the board
UART2_TXD: D12.2 (A2), F16.1; also elsewhere on the board
UART3_RXD: D30.2 (A2), F20.2; also elsewhere on the board
UART3_TXD: D29.2 (A2), F21.2; also elsewhere on the board
UART4_RXD: Q2.3 (C), R24.1; also elsewhere on the board
UART5_DE: R36.2, U7.2 (#RE), U7.3 (DE); also elsewhere on the board
UART5_RXD: R35.1, U7.1 (R_OUT); also elsewhere on the board
UART5_TXD: U7.4 (D_IN); also elsewhere on the board
UART6_RXD: D19.2 (A2), F22.1; also elsewhere on the board
UART6_TXD: D21.2 (A2), F23.1; also elsewhere on the board
User_Key: C51.1, KEY2.2, R34.1; also elsewhere on the board
WAKEUP: C50.2, R33.2; also elsewhere on the board

Notes on the sheet:
DEBUG LED
FLASH
485/UART外置陀螺仪
BUZZER
复位按键
IMU加热电路
CAN
UART2
Referee
BOOT&WAKEUP
DBUS
IMU
RESET&User_Key
PWM OUTPUT
JTAG&DEBUG
User_Key

Parts:
C30, C31: 12pF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C32: 100nF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
D9: SD103AWS; D_SOD-323
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R6: 1M; R_0402_1005Metric
R19: 10K; R_0402_1005Metric
R20: 4.7K; R_0402_1005Metric
RR1: 4.7K; R_0402_1005Metric
U3: HPM5361ICB1; LQFP-100_14x14mm_P0.5mm
U5: USBLC6-2SC6; SOT-23-6
Y1: 24M; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+5V: D9.1 (K); also elsewhere on the board
GND: C30.2, C31.1, C32.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R20.2, RR1.2, U5.2 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: J1.A5 (CC1), R20.1
unnamed: J1.B5 (CC2), RR1.1
unnamed: J1.A6 (D+), J1.B6 (D+), U5.6 (I/O1)
unnamed: J1.A7 (D-), J1.B7 (D-), U5.4 (I/O2)
unnamed: C32.2, R19.2, U3.68 (USBVBUS)
unnamed: C30.1, R6.2, U3.74 (XTALI), Y1.3
unnamed: C31.2, R6.1, U3.75 (XTALO), Y1.1
RESET: U3.26 (RESETN); also elsewhere on the board
USB_DM: U3.73 (USB_DM), U5.3 (I/O2)
USB_DP: U3.72 (USB_DP), U5.1 (I/O1)
VBUS: D9.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R19.1, U5.5 (VBUS)
WAKEUP: U3.27 (WAKEUP); also elsewhere on the board
