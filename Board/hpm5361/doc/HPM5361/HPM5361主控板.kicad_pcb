# Repository liqunmaster/Dust_HeavyRobot (continued)

## KiCad design Board/hpm5361/doc/HPM5361/HPM5361主控板.kicad_pcb (continued)

Parts:
C4: 10uF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C5, C6, C9: 22uF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C7, C8, C11, C18, C19, C20, C21, C22, C23, C24, C25, C26, C70: 100nF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C10, C27: 4.7uF; C_0402_1005Metric; Voltage 1kV; Tolerance 100%
C55, C64, C65: 10uF; C_0603_1608Metric
C66: 100nF; C_0603_1608Metric
C67: 100nF; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
C68, C75: 22uF 10V; C_1206_3216Metric
C69: 47uF; C_1206_3216Metric; Voltage 1kV; Tolerance 100%
C71, C74: 4.7uF; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
C72, C73: 22uF; C_1206_3216Metric; Voltage 1kV; Tolerance 100%
D1: BZT52C12S WH; D_SOD-323
D2: Blue; LED_0603_1608Metric
D31: SMBJ30A; D_SMB
L1: NLV25T-4R7J-PF; L_1008_2520Metric
L2: 4.7uH; L_APV_APH0420
L8: 3.3UH; L_APV_APH0630
Q1: AGM60P100A; PQFN-8-EP_6x5mm_P1.27mm_Generic
R1, R3: 10K; R_0402_1005Metric
R4: 10K; R_0603_1608Metric
R5: 0; R_0402_1005Metric
R15: 62K; R_0603_1608Metric
R16: 20K; R_0603_1608Metric
R53, R54: 100K; R_0402_1005Metric
R55: 19.1K; R_0402_1005Metric
R56: 14.7K; R_0402_1005Metric
U3: HPM5361ICB1; LQFP-100_14x14mm_P0.5mm
U13: RY8411; SOT-23-6
U14: LMR51450; WSON-12-1EP_3x3mm_P0.5mm_EP1.5x2.5mm
XT1: AMASS_XT30U-M_1x02_P5.0mm_Vertical

Connections:
+3.3V: C7.2, C9.2, C10.1, C11.1, C18.2, C27.2, C68.1, C75.1, L2.2, R15.2, U3.30 (DCDC_IN), U3.65 (VREFH), U3.67 (VANA); also elsewhere on the board
+5V: C55.1, C64.1, C65.1, C69.2, C72.2, C73.2, L8.2, R53.2, R54.2, U13.4 (EN), U13.5 (IN); also elsewhere on the board
DCDC_LP: L1.2, U3.29 (DCDC_LP)
GND: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C55.2, C64.2, C65.2, C68.2, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.2, D2.1 (K), D31.2 (A2), R1.2, R16.1, R55.1, R56.1, U3.8 (VSS), U3.10 (VSS), U3.16 (VSS), U3.22 (VSS), U3.28 (DCDC_GND), U3.32 (VSS), U3.43 (VSS), U3.56 (VSS), U3.64 (VREFL), U3.66 (VSS), U3.70 (VSS), U3.76 (VSS), U3.84 (VSS), U3.95 (VSS), U13.2 (GND), U14.8 (GND), U14.13 (PAD), XT1.1 (-); also elsewhere on the board
unnamed: C67.2, L8.1, U14.1 (SW), U14.2 (SW), U14.3 (SW)
unnamed: D1.2 (A), Q1.G, R1.1, R3.2
unnamed: D2.2 (A), R4.2
unnamed: C5.2, C6.2, C8.2, L1.1, R5.2, U3.21 (DCDC_SNS)
unnamed: C66.2, U13.1 (BS)
unnamed: R15.1, R16.2, U13.3 (FB)
unnamed: C66.1, L2.1, U13.6 (LX)
unnamed: C67.1, U14.4 (BOOT)
unnamed: R54.1, R55.2, U14.7 (FB)
unnamed: R53.1, U14.5 (PG)
unnamed: R56.2, U14.6 (RT)
VDD_SOC: C4.2, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, R5.1, U3.7 (VDD_SOC), U3.17 (VDD_SOC), U3.20 (VDD_SOC), U3.44 (VDD_SOC), U3.57 (VDD_SOC), U3.69 (VDD_SOC), U3.83 (VDD_SOC), U3.94 (VDD_SOC)
VIN: C70.2, C71.2, C74.2, D1.1 (K), Q1.S, R3.1, R4.1, U14.9 (EN), U14.10 (VIN), U14.11 (VIN), U14.12 (VIN)
VIN1: D31.1 (A1), Q1.D, XT1.2 (+)

Notes on the sheet:
24V转5V
输入防反接
5V转3.3V
HPM5361PWOMER

Board: 4 copper layers, 54.3 x 40.0 mm, 189 parts (94 on the bottom side), 124 nets.

## Code that names these connections

File Board/hpm5361/hpm5361icb.dts:

/*
 * Copyright 2026 Dust Robotics
 * SPDX-License-Identifier: Apache-2.0
 *
 * Dust HeavyHero HPM5361ICB main board.
 * Base wiring and defaults for the custom board. Application overlays may
 * adjust peripheral speed, bitrate and DMA settings.
 */

/dts-v1/;

#include <hpmicro/hpm5361.dtsi>
#include "hpm5361icb-pinctrl.dtsi"

/* Zephyr 4.4 uses isa-base/isa-extensions; remove HPM's legacy alias. */
&cpu0 {
	/delete-property/ riscv,isa;
	riscv,isa-extensions = "m", "a", "f", "c", "zicsr", "zifencei";
};

/ {
	model = "Dust HeavyHero HPM5361ICB";
	compatible = "hpmicro,hpm5361icb";

	aliases {
		can0 = &can0;
	};

	chosen {
		zephyr,console = &uart3;
		zephyr,shell-uart = &uart3;
		zephyr,sram = &dlm;
		zephyr,itcm = &ilm;
		zephyr,dtcm = &dlm;
		zephyr,flash = &flash0;
		zephyr,flash-controller = &xpi0;
	};

	soc {
		ahb_sram: memory@f0400000 {
			compatible = "zephyr,memory-region";
			reg = <0xf0400000 DT_SIZE_K(32)>;
			zephyr,memory-region = "AHB_SRAM";
		};

		/* UART1: external connector on PY07/PY06. */
		uart1: serial@f0044000 {
			compatible = "hpmicro,hpm-uart";
			reg = <0xf0044000 0x1000>;
			interrupts = <14 1>, <5 1>;
			interrupt-names = "uart", "idletimer";
			clocks = <&clk CLOCK_UART1 CLK_SRC_OSC24M 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
		};

		/* UART2: VT02/VT03 shared figure-transmission interface */
		uart2: serial@f0048000 {
			compatible = "hpmicro,hpm-uart";
			reg = <0xf0048000 0x1000>;
			interrupts = <15 1>, <5 1>;
			interrupt-names = "uart", "idletimer";
			clocks = <&clk CLOCK_UART2 CLK_SRC_OSC24M 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
		};

		/* UART3: debug console / redefined printf */
		uart3: serial@f004c000 {
			compatible = "hpmicro,hpm-uart";
			reg = <0xf004c000 0x1000>;
			interrupts = <16 1>, <5 1>;
			interrupt-names = "uart", "idletimer";
			clocks = <&clk CLOCK_UART3 CLK_SRC_OSC24M 1>;
			interrupt-parent = <&plic>;
			status = "okay";
		};

		/* UART4: DT7 remote receiver */
		uart4: serial@f0050000 {
			compatible = "hpmicro,hpm-uart";
			reg = <0xf0050000 0x1000>;
			interrupts = <17 1>, <5 1>;
			interrupt-names = "uart", "idletimer";
			clocks = <&clk CLOCK_UART4 CLK_SRC_OSC24M 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
		};

		/* UART5: external connector on PA23/PA22, with PA21 DE. */
		uart5: serial@f0054000 {
			compatible = "hpmicro,hpm-uart";
			reg = <0xf0054000 0x1000>;
			interrupts = <18 1>, <5 1>;
			interrupt-names = "uart", "idletimer";
			clocks = <&clk CLOCK_UART5 CLK_SRC_OSC24M 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
		};

		/* UART6: external connector on PA24/PA25. */
		uart6: serial@f0058000 {
			compatible = "hpmicro,hpm-uart";
			reg = <0xf0058000 0x1000>;
			interrupts = <19 1>, <5 1>;
			interrupt-names = "uart", "idletimer";
			clocks = <&clk CLOCK_UART6 CLK_SRC_OSC24M 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
		};

		/* SPI1: external W25Q128 log flash, not the XIP boot flash. */
		spi1: spi@f0074000 {
			compatible = "hpmicro,hpm-spi";
			reg = <0xf0074000 0x4000>;
			clocks = <&clk CLOCK_SPI1 CLK_SRC_OSC24M 1>;
			interrupts = <26 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
			#address-cells = <1>;
			#size-cells = <0>;
		};

		/* SPI2: ICM-42688P-HXY IMU */
		spi2: spi@f0078000 {
			compatible = "hpmicro,hpm-spi";
			reg = <0xf0078000 0x4000>;
			clocks = <&clk CLOCK_SPI2 CLK_SRC_OSC24M 1>;
			interrupts = <27 1>;
			interrupt-parent = <&plic>;
			status = "disabled";
			#address-cells = <1>;
			#size-cells = <0>;
			cs-sck-delay = <3>;
			cs-minimum-high-time = <11>;
		};

		/* CAN0: friction wheels */
		can0: can@f0280000 {
			compatible = "hpmicro,hpm-mcan";
			reg = <0xf0280000 0x1000>;
			interrupts = <35 1>;
			interrupt-parent = <&plic>;
			clk-name = <CLOCK_CAN0>;
			clk-source = <CLK_SRC_PLL0_CLK0>;
			clk-divider = <10>;
			status = "disabled";
		};

		/* CAN1: chassis */
		can1: can@f0284000 {
			compatible = "hpmicro,hpm-mcan";
			reg = <0xf0284000 0x1000>;
			interrupts = <36 1>;
			interrupt-parent = <&plic>;
			clk-name = <CLOCK_CAN1>;
			clk-source = <CLK_SRC_PLL0_CLK0>;
			clk-divider = <10>;
			status = "disabled";
		};

		/* CAN2: gimbal / loader */
		can2: can@f0288000 {
			compatible = "hpmicro,hpm-mcan";
			reg = <0xf0288000 0x1000>;
			interrupts = <37 1>;
			interrupt-parent = <&plic>;
			clk-name = <CLOCK_CAN2>;
			clk-source = <CLK_SRC_PLL0_CLK0>;
			clk-divider = <10>;
			status = "disabled";
		};

		/* CAN3: gimbal / loader */
		can3: can@f028c000 {
			compatible = "hpmicro,hpm-mcan";
			reg = <0xf028c000 0x1000>;
			interrupts = <38 1>;
			interrupt-parent = <&plic>;
			clk-name = <CLOCK_CAN3>;
			clk-source = <CLK_SRC_PLL0_CLK0>;
			clk-divider = <10>;
			status = "disabled";
		};

		pwm0: pwm@f0318000 {
			compatible = "hpmicro,hpm-pwm";
			reg = <0xf0318000 0x4000>;
			clocks = <&clk CLOCK_MOT0 CLOCK_AHB 1>;
			#pwm-cells = <3>;
			period-init = <1000>;
			dead-zone-in-half-cycle = <0>;
			status = "disabled";
		};

		pwm1: pwm@f031c000 {
			compatible = "hpmicro,hpm-pwm";
			reg = <0xf031c000 0x4000>;
			clocks = <&clk CLOCK_MOT0 CLOCK_AHB 1>;
			#pwm-cells = <3>;
			period-init = <1000>;
			dead-zone-in-half-cycle = <0>;
			status = "disabled";
		};
	};
};

&uart0 {
	pinctrl-0 = <&pinmux_uart0>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

&uart1 {
	pinctrl-0 = <&pinmux_uart1>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

&uart2 {
	pinctrl-0 = <&pinmux_uart2>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

&uart3 {
	pinctrl-0 = <&pinmux_uart3>;
	pinctrl-names = "default";
	current-speed = <115200>;
};

&uart4 {
	pinctrl-0 = <&pinmux_uart4>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

&uart5 {
	pinctrl-0 = <&pinmux_uart5>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

&uart6 {
	pinctrl-0 = <&pinmux_uart6>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

&spi1 {
	pinctrl-0 = <&pinmux_spi1>;
	pinctrl-names = "default";
	dmas = <&hdma 4 0x2a>, <&hdma 5 0x2b>;
	dma-names = "rx", "tx";
	status = "okay";

	w25q128: flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <12000000>;
		jedec-id = [ef 40 18];
		size = <134217728>;
		status = "okay";

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			log_partition: partition@0 {
				label = "logs";
				reg = <0x0 DT_SIZE_M(16)>;
			};
		};
	};
};

&spi2 {
	pinctrl-0 = <&pinmux_spi2>;
	pinctrl-names = "default";
	/* HDMA channels 6/7 muxed to SPI2 RX/TX */
	dmas = <&hdma 6 0x2c>, <&hdma 7 0x2d>;
	dma-names = "rx", "tx";
	status = "okay";
};

&pwm0 {
	pinctrl-0 = <&pinmux_pwm0>;
	pinctrl-names = "default";
	status = "okay";
};

&pwm1 {
	pinctrl-0 = <&pinmux_pwm1>;
	pinctrl-names = "default";
	status = "okay";
};

&can0 {
	pinctrl-0 = <&pinmux_board_can0>;
	pinctrl-names = "default";
	status = "okay";
};

&can1 {
	pinctrl-0 = <&pinmux_board_can1>;
	pinctrl-names = "default";
	status = "okay";
};

&can2 {
	pinctrl-0 = <&pinmux_board_can2>;
	pinctrl-names = "default";
	status = "okay";
};

&can3 {
	pinctrl-0 = <&pinmux_board_can3>;
	pinctrl-names = "default";
	status = "okay";
};

&gpioa {
	status = "okay";
};

&gpiob {
	pinctrl-0 = <&pinmux_gpiob>;
	pinctrl-names = "default";
	status = "okay";
};

&gpioy {
	pinctrl-0 = <&pinmux_gpioy>;
	pinctrl-names = "default";
	status = "okay";
};

&hdma {
	status = "okay";
};

&xpi0 {
	status = "okay";
	flash0: flash@80000000 {
		compatible = "hpmicro,hpmicro-flash", "soc-nv-flash";
		reg = <0x80000000 DT_SIZE_M(1)>;
		status = "okay";
		erase-block-size = <4096>;
		write-block-size = <1>;
		nor-cfg-opt-hdr = <0xfcf90002>;
		nor-cfg-opt-opt0 = <0x05>;
		nor-cfg-opt-opt1 = <0x1000>;

		/* The SDK flash page-layout driver requires these partition labels.
		 * They cover only the 1 MiB boot flash; this board does not use MCUboot.
		 */
		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			boot_partition: partition@3000 {
				label = "page-layout-header";
				reg = <0x3000 0x1000>;
			};

			slot0_partition: partition@4000 {
				label = "page-layout-main";
				reg = <0x4000 0xf9000>;
			};

			slot1_partition: partition@fd000 {
				label = "reserved-slot1";
				reg = <0xfd000 0x1000>;
			};

			scratch_partition: partition@fe000 {
				label = "reserved-scratch";
				reg = <0xfe000 0x1000>;
			};

			storage_partition: partition@ff000 {
				label = "reserved-storage";
				reg = <0xff000 0x1000>;
			};
		};
	};
};
